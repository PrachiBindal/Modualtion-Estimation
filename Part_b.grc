options:
  parameters:
    generate_options: qt_gui
    id: ex1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: exponent
  id: variable
  parameters:
    value: '4'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '32768'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '400000'
  states: {}
- name: blocks_exponentiate_const_cci_0
  id: blocks_exponentiate_const_cci
  parameters:
    comment: frequency offset is 90/4 =22.5
    exponent: exponent
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\prach\Downloads\file63.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_0_1_2
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: fft_size
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1024'
    interp: '400'
    type: ccc
  states: {}

connections:
- [blocks_exponentiate_const_cci_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0_1_2, '0']
- [rational_resampler_xxx_0, '0', blocks_exponentiate_const_cci_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
